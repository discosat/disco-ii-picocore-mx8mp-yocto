MIRRORS = " https://git.alsa-project.org/tinycompress.git;protocol=git;branch=master \
            https://git.alsa-project.org/http/tinycompress.git;protocol=git;branch=master "
