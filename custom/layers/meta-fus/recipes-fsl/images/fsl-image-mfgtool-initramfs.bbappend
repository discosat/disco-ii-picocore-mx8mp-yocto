# Remove u-boot-mfgtool dependency
# for it expects UBOOT_CONFIG
# instead of UBOOT_MACHINE

DEPENDS:remove = "u-boot-mfgtool"
