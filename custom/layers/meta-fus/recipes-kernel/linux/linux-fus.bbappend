SRC_URI = "git://github.com/discosat/linux-fus.git;nobranch=1;protocol=https"
SRCREV = "034fc964b73bcb7a27ce1b9bbcfbebd1a88d0360"
