#FuS alsa-state should be used


# Update asound.conf for all SoC
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"


