SRC_URI = "git://github.com/discosat/u-boot-fus.git;nobranch=1;protocol=https"
SRCREV = "acbad3e4153b4d443d41b488cb0f71384601a01b"
